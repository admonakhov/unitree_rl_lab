Commit message: arcus new legs cfg

File: robots/arcus/a1_2/Arcus_1.urdf (robot description, URDF)
Before this commit: robot Arcus2.SLDASM, 28 links, 27 joints
Links:
- link pelvis: mass 4.80596321102675 -> 3.813
